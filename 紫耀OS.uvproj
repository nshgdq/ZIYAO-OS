# Keil uVision project 紫耀OS.uvproj, settings and files
target stc12c5a60s2 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 紫耀OS +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\user\Include
  link misc: RECURSIONS (100)
  group sys
    ./: STARTUP.A51
  group App
    ./user/App/: calendar.c startch.c picbox.c ledctrl.c tempert.c sys_app.c
  group Driver
    ./user/Driver/: 18b20.c ATCmd.c audio.c ds1302.c HX8347D.c led.c timer.c Touch.c uart.c W25Qxx.c
  group Main
    ./user/: main.c
